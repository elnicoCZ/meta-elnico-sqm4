FILESEXTRAPATHS_prepend := "${THISDIR}/qt4:"

SRC_URI_append_vf60 += "file://qt-embedded-linux-4.8.3-24bit-bgr.patch"
